FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append := " file://0001-add-ili9341-device-tree.patch"